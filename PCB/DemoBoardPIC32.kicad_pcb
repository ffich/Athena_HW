# Repository ffich/Athena_HW (continued)

## KiCad design PCB/DemoBoardPIC32.kicad_pcb (continued)

Board: 2 copper layers, 138 parts (0 on the bottom side), 126 nets.

Other parts of the board:
Scr: 1pin
Scr#2, Scr#3, Scr#4: 1pin

## Commit log

2025-08-12 Update README.md
    added description
