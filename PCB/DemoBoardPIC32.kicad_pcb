# Repository ffich/Athena_HW

File README.md:

# 🛠⚡ Athena_HW — Open-Source Hardware for Athena PIC32 EVB  

Welcome to the **Athena Hardware Repository** — your complete **KiCad** project for the **Athena PIC32 Evaluation Board** 🖥🐉.  
Everything you need to **build, modify, and manufacture** the board is right here.  

---

## 📖 What’s Inside?  

This repo contains **all hardware design assets** for the Athena PIC32 EVB:  

- 🗺 **Schematics** — Clear circuit diagrams for every connection  
- 📐 **PCB Layouts** — Fully routed KiCad board designs  
- 📦 **BOM (Bill of Materials)** — All components with part references  
- 🖼 **3D Models** — STEP and render files for enclosure & preview  
- 📄 **Gerber Files** — Manufacturing-ready outputs for PCB fabrication  

---

## 🚀 Why Athena EVB Rocks  

- ⚡ **High-Performance PIC32 MCU** — Perfect for real-time control and embedded apps  
- 🔌 **Plenty of I/O** — UART, SPI, I²C, ADC, PWM, GPIOs all accessible  
- 🛠 **Customizable** — Modify connectors, add sensors, tweak for your needs  
- 🎓 **Educational** — Great learning platform for PCB design & microcontroller systems  
- 🏭 **Production-Ready** — Files ready to send straight to your PCB manufacturer  

---

## 📂 Repository Structure  

| 📁 Folder | 📜 Contents |
|-----------|------------|
| 🗺 `SCH/` | KiCad schematic files |
| 📐 `PCB/` | KiCad PCB layout files |
| 📦 `_BOM/` | Bill of Materials |
| 🖼 `_3D/` | 3D board models |
| 📄 `_GERBER/` | Gerber manufacturing files |

---

## ⚙ Getting Started  

1. ⬇ **Clone** this repo  
2. 🖥 **Open** `.sch` or `.kicad_pcb` in **KiCad v6+**  
3. 🛠 **Edit** to match your project requirements  
4. 🏭 **Export Gerbers** and send to your favorite PCB fab  
5. 🔌 **Assemble & Test** your custom Athena board  

---

## 💡 Use Cases  

- 🏫 **Education** — Teaching PCB design or embedded systems  
- 🚀 **Prototyping** — Rapid development of PIC32-based projects  
- 🏭 **Product Development** — Baseboard for production hardware  
- 🤖 **Robotics** — High-speed control and sensor interfacing  

---

## 🏆 Summary  

**Athena_HW** is a **fully open-source PIC32 EVB hardware design** 🛠⚡.  
With all the KiCad files, BOM, 3D models, and Gerbers at your fingertips, you can **learn, modify, and manufacture** without barriers.  

---

## KiCad design PCB/DemoBoardPIC32.kicad_pcb

Parts:
C12, C14, C15, C16: 100nF
C13: 4.7uF
CN5: Ethernet
D12: LED
R25, R27, R33: 1.5k
R26, R28, R29, R30, R31, R47: 33
R32, R35, R36, R41, R42, R43: 2.2k
R34: 4.87k
R37, R38, R39, R40: 49.9
R44, R45: 249
R46: 510
R60: 0R
U6: DP83848C; LQFP48
Y1: 50MHZ

Connections:
+3.3V: C15.1, C16.1, CN5.3, CN5.5, CN5.6, R25.2, R27.1, R32.1, R33.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.2, R45.1, R46.1, U6.22 (AVDD33), U6.32 (IOVDD33), U6.48 (IOVDD33), Y1.1 (EN), Y1.4 (VCC); also elsewhere on the board
/Ethernet/ECRS_DV: U6.40 (CRS/CRS_DV/LED_CFG); also elsewhere on the board
/Ethernet/EMDC: U6.31 (MDC); also elsewhere on the board
/Ethernet/EMDIO: R25.1, U6.30 (MDIO); also elsewhere on the board
/Ethernet/EREF_CLK: R47.2, U6.34 (X1); also elsewhere on the board
/Ethernet/ERXD0(2): R30.1; also elsewhere on the board
/Ethernet/ERXD1(2): R31.1; also elsewhere on the board
/Ethernet/ERXERR: U6.41 (RX_ER/MDIX_EN); also elsewhere on the board
/Ethernet/EXTD0(2): R28.1; also elsewhere on the board
/Ethernet/EXTD1(2): R26.1; also elsewhere on the board
/Ethernet/EXTEN(2): R29.1; also elsewhere on the board
/Ethernet/INT3/SCL1/RA14: R27.2, U6.7 (PWR_DOWN/INT); also elsewhere on the board
/Ethernet/LED_ACT: CN5.11, R42.2, U6.26 (AN_EN/LED_ACT/COL)
/Ethernet/LED_LINK: CN5.9, R41.2, U6.28 (AN0/LED_LINK)
/Ethernet/LED_SPEED: D12.2 (K), R43.2, U6.27 (AN1/LED_SPEED)
/Ethernet/MDI_RN: CN5.7, R40.2, U6.13 (RD-)
/Ethernet/MDI_RP: CN5.8, R39.2, U6.14 (RD+)
/Ethernet/MDI_TN: CN5.1, R37.2, U6.16 (TD-)
/Ethernet/MDI_TP: CN5.2, R38.2, U6.17 (TD+)
GND: C12.2, C13.2, C14.2, C15.2, C16.2, CN5.13, CN5.14, R34.1, R60.1, U6.6 (TXD_3/SNI_MODE), U6.15 (AGND), U6.19 (AGND), U6.35 (IOGND), U6.36 (DGND), U6.47 (IOGND), Y1.2 (GND); also elsewhere on the board
unnamed: D12.1 (A), R46.2
unnamed: R36.2, U6.21 (RESERVED)
unnamed: R35.2, U6.20 (RESERVED)
unnamed: CN5.10, R45.2
unnamed: R26.2, U6.4 (TXD_1)
unnamed: R32.2, U6.39 (RX_DV/MII_MODE)
unnamed: R29.2, U6.2 (TX_EN)
unnamed: R33.2, U6.29 (~RESET~)
unnamed: R47.1, Y1.3 (OUT)
unnamed: CN5.12, R44.1
unnamed: CN5.4, R60.2
unnamed: R31.2, U6.44 (RXD_1/PHY_AD2)
unnamed: R30.2, U6.43 (RXD_0/PHY_AD1)
unnamed: R28.2, U6.3 (TXD_0)
unnamed: R34.2, U6.24 (RBIAS)
unnamed: C12.1, C13.1, C14.1, U6.18 (PFBIN1), U6.23 (PFBOUT), U6.37 (PFBIN2)

Notes on the sheet:
Ethernet Clock
Ethernet Connector
Ethernet LED Connector Pull-Up
Ethernet Driver

Parts:
C17: 100nF
C18: 220nF
C20: 4.7uF
C21: 1uF
CN2: BARREL-JACK
D13: 1N4007
D14, D15: LED
JP1: JUMPER
R48: 470
R49: 330
U7: LM340
U8: MCP1825S

Connections:
+3.3V: C21.1, R49.1, U8.3 (Vout); also elsewhere on the board
+5V: C17.1, C20.1, JP1.1, R48.1, U7.3 (Vout), U8.1 (Vin); also elsewhere on the board
/USB/+5V_EXT: JP1.2; also elsewhere on the board
GND: C17.2, C18.2, C20.2, C21.2, CN2.P2, CN2.P3, D14.2 (K), D15.2 (K), U7.2 (GND), U7.4 (GND), U8.2 (GND), U8.4 (GND); also elsewhere on the board
unnamed: CN2.P1, D13.1 (A)
unnamed: C18.1, D13.2 (K), U7.1 (Vin)
unnamed: D14.1 (A), R48.2
unnamed: D15.1 (A), R49.2

Notes on the sheet:
Voltage Regulator

Parts:
C22, C23: 100nF
D16: LED_3
D17: LED_4
J1: ICSP_PIC12
R10: 4.7k
R50, R52: 10k
R51, R53, R54, R55: 470
SW4: PIC12 USER
SW5: PIC12 RESET
U9: PIC12F1822; SOIC8

Connections:
+3.3V: J1.2, R10.1, R50.1, R52.1, U9.1 (VDD); also elsewhere on the board
/PIC12F/MCLR_PIC12: J1.1, R10.2, R53.2, U9.4 (RA3/MCLR/VPP)
/PIC12F/PIC32_RX: J1.5, U9.6 (RA1/ICSPCLK); also elsewhere on the board
/PIC12F/PIC32_TX: J1.4, U9.7 (RA0/ICSPDAT); also elsewhere on the board
/PIC12F/USER_BUTTON: R51.2, U9.5 (RA2)
/PIC12F/USER_LED_3: R54.1, U9.2 (RA5)
/PIC12F/USER_LED_4: R55.1, U9.3 (RA4)
GND: C22.2, C23.2, D16.2 (K), D17.2 (K), J1.3, SW4.3, SW5.3, U9.8 (VSS); also elsewhere on the board
unnamed: C22.1, R50.2, R51.1, SW4.1
unnamed: D17.1 (A), R55.2
unnamed: D16.1 (A), R54.2
unnamed: C23.1, R52.2, R53.1, SW5.1

Notes on the sheet:
PIC12 USER BUTTON
PIC12 USER LED
PIC12F1822
PIC12 RESET BUTTON
ICSP

Parts:
C24: 100nF
C25: 100uF
CN3: USB Device
CN4: USB Host

Connections:
+5V: C24.1, CN3.1 (VBUS); also elsewhere on the board
/PIC32MX/D+/RG2: CN3.3 (D+), CN4.3 (D+); also elsewhere on the board
/PIC32MX/D-/RG3: CN3.2 (D-), CN4.2 (D-); also elsewhere on the board
/USB/+5V_EXT: C25.1, CN4.1 (Vbus); also elsewhere on the board
GND: C24.2, C25.2, CN3.4 (ID), CN3.5 (GND), CN3.6 (SHELL1), CN3.7 (SHELL2), CN3.8 (SHELL3), CN3.9 (SHELL4), CN4.4 (GND), CN4.5 (Shield_1), CN4.6 (Shield_2); also elsewhere on the board

Notes on the sheet:
USB Device Port
USB Host Port

Parts:
C1, C2, C6: 100nF
C3: 4.7uF
C4, C5: 22pF
C26, C27: 33pF
D1: LED_1
D2: LED_2
EXP1: Expansion Header 1
EXP2: Expansion Header 2
J2: ICSP_PIC32
JOY1: JOYSTICK
R1, R3, R4, R6, R7, R8: 470
R2, R9, R12, R56, R57, R58, R59: 10k
R5: 1M
R61: 4,7k
SW1: PIC32 USER
SW2: PIC32 RESET
TRIM1, TRIM2: POT
U1: PIC32MX795F512L; TQFP
X1: 8MHz
X2: LP Crystal

Connections:
+3.3V: EXP1.2, EXP2.2, J2.2, R2.1, R9.1, R12.1, R56.1, R57.1, R58.1, R59.1, R61.2, TRIM1.3, TRIM2.3, U1.2 (VDD), U1.16 (VDD), U1.30 (AVDD), U1.37 (VDD), U1.46 (VDD), U1.55 (VUSB3V3), U1.62 (VDD), U1.86 (VDD); also elsewhere on the board
+5V: EXP1.4, EXP2.4, U1.54 (VBUS); also elsewhere on the board
/Devices/I2C_SCL: EXP1.7, U1.58 (RA2); also elsewhere on the board
/Devices/I2C_SDA: EXP1.9, U1.59 (RA3); also elsewhere on the board
/Devices/LCD_BKL_A: U1.97 (RG13); also elsewhere on the board
/Devices/LCD_D0: U1.96 (RG12); also elsewhere on the board
/Devices/LCD_D1: U1.95 (RG14); also elsewhere on the board
/Devices/LCD_D2: U1.94 (RE1); also elsewhere on the board
/Devices/LCD_D3: U1.93 (RE0); also elsewhere on the board
/Devices/LCD_D4: EXP2.19, U1.92 (RA7); also elsewhere on the board
/Devices/LCD_D5: EXP2.17, U1.91 (RA6); also elsewhere on the board
/Devices/LCD_D6: EXP2.15, U1.90 (RG0); also elsewhere on the board
/Devices/LCD_D7: EXP2.13, U1.89 (RG1); also elsewhere on the board
/Devices/LCD_EN: EXP2.23, U1.100 (RE4); also elsewhere on the board
/Devices/LCD_RS: EXP2.21, U1.98 (RE2); also elsewhere on the board
/Devices/LCD_RW: U1.99 (RE3); also elsewhere on the board
/Devices/LED_DRIVER_RESET: U1.61 (RA5); also elsewhere on the board
/Devices/SCK_1: U1.70 (RD10); also elsewhere on the board
/Devices/SCK_4: U1.39 (RF13); also elsewhere on the board
/Devices/SDI_1: U1.9 (RC4); also elsewhere on the board
/Devices/SDI_4: U1.49 (RF4); also elsewhere on the board
/Devices/SDO_1: U1.72 (RD0); also elsewhere on the board
/Devices/SDO_4: U1.50 (RF5); also elsewhere on the board
/Devices/SD_DAT1: U1.7 (RC2); also elsewhere on the board
/Devices/SD_DAT2: U1.17 (RA0); also elsewhere on the board
/Devices/SS_1: U1.69 (RD9); also elsewhere on the board
/Devices/SS_4: U1.40 (RF12); also elsewhere on the board
/Devices/mSD_Detect_B: U1.88 (RF1); also elsewhere on the board
/Ethernet/ECRS_DV: U1.12 (RG8); also elsewhere on the board
/Ethernet/EMDC: U1.71 (RD11); also elsewhere on the board
/Ethernet/EMDIO: U1.68 (RD8); also elsewhere on the board
/Ethernet/EREF_CLK: U1.14 (RG9); also elsewhere on the board
/Ethernet/ERXD0(2): U1.18 (RE8); also elsewhere on the board
/Ethernet/ERXD1(2): U1.19 (RE9); also elsewhere on the board
/Ethernet/ERXERR: U1.1 (RG15); also elsewhere on the board
/Ethernet/EXTD0(2): U1.47 (RD14); also elsewhere on the board
/Ethernet/EXTD1(2): U1.48 (RD15); also elsewhere on the board
/Ethernet/EXTEN(2): U1.67 (RA15); also elsewhere on the board
/Ethernet/INT3/SCL1/RA14: U1.66 (RA14); also elsewhere on the board
/PIC12F/PIC32_RX: EXP2.24, U1.52 (RF2); also elsewhere on the board
/PIC12F/PIC32_TX: EXP2.22, U1.53 (RF8); also elsewhere on the board
/PIC32MX/Caps: C2.2, C3.2, U1.85 (VCAP/VDDCORE)
/PIC32MX/D+/RG2: EXP2.5, U1.57 (D+/RG2); also elsewhere on the board
/PIC32MX/D-/RG3: EXP2.3, U1.56 (D-/RG3); also elsewhere on the board
/PIC32MX/EXP_POT_1: R7.2, TRIM1.2
/PIC32MX/EXP_POT_2: R8.2, TRIM2.2
/PIC32MX/FIRE_BUTTON: R1.2, U1.32 (RB8)
/PIC32MX/GPIO1_CN0: C26.1, EXP1.11, U1.74 (RC14), X2.1
/PIC32MX/GPIO2_CN1: C27.1, EXP1.13, U1.73 (RC13), X2.2
/PIC32MX/GPIO5_IC5: EXP2.11, U1.79 (RD12)
/PIC32MX/GPIO6_CN19: EXP2.9, U1.80 (RD13)
/PIC32MX/GPIO7_OC5: EXP2.7, U1.81 (RD4)
/PIC32MX/J_DOWN: EXP1.21, JOY1.5 (D), R59.2, U1.41 (RB12)
/PIC32MX/J_FIRE: EXP1.23, JOY1.6 (F), R58.2, U1.42 (RB13)
/PIC32MX/J_LEFT: EXP1.15, JOY1.1 (A), R57.2, U1.35 (RB11)
/PIC32MX/J_RIGHT: EXP1.19, JOY1.3 (C), R12.2, U1.34 (RB10)
/PIC32MX/J_UP: EXP1.17, JOY1.2 (B), R56.2, U1.33 (RB9)
/PIC32MX/MCLR_PIC32: J2.1, R6.2, R61.1, U1.13 (MCLR)
/PIC32MX/OSC1: C4.1, R5.2, U1.63 (OSC1/CLKI/RC12), X1.1
/PIC32MX/OSC2: C5.1, R5.1, U1.64 (OSC2/CLKO/RC15), X1.2
/PIC32MX/PGC: J2.5, U1.24 (PGEC)
/PIC32MX/PGD: J2.4, U1.25 (PGED)
/PIC32MX/UESR_LED2: EXP1.3, R4.1, U1.77 (RD2)
/PIC32MX/USER_LED1: EXP1.5, R3.1, U1.76 (RD1)
/PIC32MX/USER_POT1: R7.1, U1.26 (RB6)
/PIC32MX/USER_POT2: R8.1, U1.27 (RB7)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C26.2, C27.2, D1.2 (K), D2.2 (K), EXP1.1, EXP2.1, J2.3, JOY1.4 (G), SW1.3, SW2.3, TRIM1.1, TRIM2.1, U1.15 (VSS), U1.31 (AVSS), U1.36 (VSS), U1.45 (VSS), U1.65 (VSS), U1.75 (VSS); also elsewhere on the board
GP0: EXP1.10; also elsewhere on the board
GP1: EXP1.12; also elsewhere on the board
GP2: EXP1.14; also elsewhere on the board
GP3: EXP1.16; also elsewhere on the board
GP4: EXP1.18; also elsewhere on the board
GP5: EXP1.20; also elsewhere on the board
GP6: EXP1.22; also elsewhere on the board
GP7: EXP1.24; also elsewhere on the board
unnamed: D2.1 (A), R4.2
unnamed: D1.1 (A), R3.2
unnamed: C1.1, R1.1, R2.2, SW1.1
unnamed: C6.1, R6.1, R9.2, SW2.1

Notes on the sheet:
PIC32 MX
PIC32 Reset Button
PIC32 Oscillators
PIC32 User LED
PIC32 Potentiometer
PIC32 Expansion Connector
ICSP
Joystick

Parts:
C7, C8, C9, C10, C11: 100nF
CN1: MICROSD
D3, D4, D5, D6, D7, D8, D9, D10, D11: LED
R11, R17, R19, R24: 4.7k
R13, R14, R15, R16, R18, R20, R21, R22: 470
R23: 10k
TRIM3: CONTRAST
U2: 24LC16B; SOIC8
U3: MCP23008; SOIC-18
U4: MIDAS MC21605C6W-SPR
U5: TC72; MSOP

Connections:
+3.3V: C7.1, C8.1, C10.1, C11.1, CN1.4 (VDD), R17.1, R19.1, R23.1, R24.1, U2.8 (Vcc), U3.18 (Vdd), U5.8 (Vdd); also elsewhere on the board
+5V: C9.1, TRIM3.3, U4.2 (Vdd); also elsewhere on the board
/Devices/I2C_SCL: R19.2, U2.6 (SCL), U3.1 (SCL); also elsewhere on the board
/Devices/I2C_SDA: R17.2, U2.5 (SDA), U3.2 (SDA); also elsewhere on the board
/Devices/LCD_BKL_A: U4.15 (Backlight_An); also elsewhere on the board
/Devices/LCD_D0: U4.7 (D0); also elsewhere on the board
/Devices/LCD_D1: U4.8 (D1); also elsewhere on the board
/Devices/LCD_D2: U4.9 (D2); also elsewhere on the board
/Devices/LCD_D3: U4.10 (D3); also elsewhere on the board
/Devices/LCD_D4: U4.11 (D4); also elsewhere on the board
/Devices/LCD_D5: U4.12 (D5); also elsewhere on the board
/Devices/LCD_D6: U4.13 (D6); also elsewhere on the board
/Devices/LCD_D7: U4.14 (D7); also elsewhere on the board
/Devices/LCD_EN: U4.6 (EN); also elsewhere on the board
/Devices/LCD_RS: U4.4 (RS); also elsewhere on the board
/Devices/LCD_RW: U4.5 (RW); also elsewhere on the board
/Devices/LED_DRIVER_RESET: U3.6 (RESET); also elsewhere on the board
/Devices/SCK_1: CN1.5 (CLK); also elsewhere on the board
/Devices/SCK_4: U5.3 (SCK); also elsewhere on the board
/Devices/SDI_1: CN1.3 (CMD); also elsewhere on the board
/Devices/SDI_4: U5.6 (SDI); also elsewhere on the board
/Devices/SDO_1: CN1.7 (DAT0); also elsewhere on the board
/Devices/SDO_4: U5.5 (SDO); also elsewhere on the board
/Devices/SD_DAT1: CN1.8 (DAT1); also elsewhere on the board
/Devices/SD_DAT2: CN1.1 (DAT2); also elsewhere on the board
/Devices/SS_1: CN1.2 (CD/DAT3), D11.2 (K), R23.2; also elsewhere on the board
/Devices/SS_4: U5.2 (CS); also elsewhere on the board
/Devices/Vo: TRIM3.2, U4.3 (Cont)
/Devices/mSD_Detect_B: CN1.CD1; also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, CN1.6 (VSS), D3.2 (K), D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), D9.2 (K), D10.2 (K), R11.2, TRIM3.1, U2.1 (A0), U2.2 (A1), U2.3 (A2), U2.4 (Vss), U3.3 (A2), U3.4 (A1), U3.5 (A0), U3.9 (Vss), U4.1 (Vss), U4.16 (Backlight_Gnd), U5.4 (GND); also elsewhere on the board
GP0: R13.1, U3.10 (GP0); also elsewhere on the board
GP1: R14.1, U3.11 (GP1); also elsewhere on the board
GP2: R15.1, U3.12 (GP2); also elsewhere on the board
GP3: R16.1, U3.13 (GP3); also elsewhere on the board
GP4: R18.1, U3.14 (GP4); also elsewhere on the board
GP5: R20.1, U3.15 (GP5); also elsewhere on the board
GP6: R21.1, U3.16 (GP6); also elsewhere on the board
GP7: R22.1, U3.17 (GP7); also elsewhere on the board
unnamed: D10.1 (A), R22.2
unnamed: D3.1 (A), R13.2
unnamed: D7.1 (A), R18.2
unnamed: D8.1 (A), R20.2
unnamed: D9.1 (A), R21.2
unnamed: D4.1 (A), R14.2
unnamed: D5.1 (A), R15.2
unnamed: D6.1 (A), R16.2
unnamed: D11.1 (A), R24.2
unnamed: R11.1, U2.7 (WP)

Notes on the sheet:
Temp Sensor
Display LCD
EEPROM
Led Driver
I2C NETWORK
SPI DEVICES
SD Card Slot
I2C Pull-Up Resistors
External GP Conns
